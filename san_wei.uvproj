# Keil uVision project san_wei.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: san_wei
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\app;.\CM3;.\driver;.\STM32F10x_FWLib\src;.\config;.\OS32;.\STM32F10x_FWLib\inc;.\system;.\gui\CORE;.\gui\Config;.\gui\WM;.\gui\INC;.\gui\LCDDriver;.\gui\Font;.\gui\MemDev;.\gui\ConvertMono;.\HARDWARE\LCD;.\ucos_ii\config;.\ucos_ii\PORT;.\ucos_ii\my_test
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./config/: config.c
    ./CM3/: startup_stm32f10x_hd.s
  group app
    ./app/: main.c delay.c PowerMachineFault.c monitoring.c
  group driver
    ./driver/: DriverIt.c DriverSystick.c DriverUsart4.c PGA204.c DriverSPI.c DriverEXTLine.c gui.c DeviceFsmc.c
    ./HARDWARE/AD7606/: AD.c AD7606.c
    ./app/: 1335.C DA7545.C
  group Core
    ./CM3/: CPU.S core_cm3.c
    ./OS32/: MyTask .c OS004_Sleep.c
  group stm32f103x
    ./STM32F10x_FWLib/src/: stm32f10x_tim.c stm32f10x_systick.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_bkp.c system_stm32f10x.c misc.c stm32f10x_gpio.c stm32f10x_usart.c
  group gui_config
    ../sanwei/陈柱任/STM32/STM32/4，程序源码/标准例程/实验57 ucGUI实验/uCGUI/Config/: GUIConf.h GUITouchConf.h LCDConf.h
  group ucos_ii
    ./ucos_ii/my_test/: my_test.c
    ./ucos_ii/PORT/: os_cpu_a.asm
